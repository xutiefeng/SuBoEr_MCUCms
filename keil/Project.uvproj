# Keil uVision project Project.uvproj, settings and files
target Project (MCS-51)
  device: CMS8S6990 Cmsemicon
  cpu: IRAM(0 - 0xFF) IROM(0-0x3FFF) XRAM(0x0000-0x03FF) CLOCK(24000000) MODDP2
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Libary\Device\CMS8S6990\Include;..\Libary\StdDriver\inc;..\code;..\u8g2;..\GUI
  link misc: REMOVEUNUSED
  group CMS
    ../Libary/Device/CMS8S6990/Include/: cms8s6990.h
    ../Libary/Device/CMS8S6990/: startup_cms8s6990.A51
  group bsp
    ../BSP/: clib.c globe.c sysRun.c Bsp_Phykey.c FuncLogic_key.c FuncTab.c
  group LIB
    ../Libary/StdDriver/src/: acmp.c adc.c buzzer.c epwm.c extint.c flash.c gpio.c i2c.c lse.c opa.c pga.c spi.c system.c timer.c uart.c wdt.c
  group User
    ../code/: isr.c main.c
  group Oled
    ../GUI/: gui.c
    $TC_ROOT$/../../tfxu/Code/ToolCode_OLED_Suppor/ToolCode_OLED_Suppor/u8g2/: u8g2.h
    ../u8g2/: u8x8.h u8x8_d_ssd1306_128x64_noname.c u8g2_d_memory.c u8g2_d_setup.c u8g2_fonts.c
